# Enable gnutls or openssl, not both
PACKAGECONFIG = "expat openssl libproxy webdav zlib"
PACKAGECONFIG_class-native = "expat openssl webdav zlib"


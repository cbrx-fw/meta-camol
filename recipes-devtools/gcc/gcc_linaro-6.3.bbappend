FILESEXTRAPATHS_append := "${THISDIR}/files"

SRC_URI += "file://ubsan-fix-check-empty-string.patch"
